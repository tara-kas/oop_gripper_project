Commit message: Grasping + 3-finger-gripper

File: objects/cylinder.urdf (robot description, URDF)
Before this commit: robot cylinder_robot, 1 links, 0 joints
Links:
- link cylinder_link: geometry collision cylinder length=0.15 radius=0.025; visual cylinder length=0.15 radius=0.025
